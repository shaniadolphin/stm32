# Keil uVision project minibalanceos.uvprojx, settings and files
target minibalanceos (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-ucos +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,  USE_STM3210B_EVAL
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\CM3;..\MiniBalance
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/: stm32f10x_startup.s
  group APP
    ./: app.c stm32f10x_it.c spi.c msg.c
  group CONTROL
    ../MiniBalance/: control.c filter.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/usart/: usart.c
    ../BSP/LCD/: LCD.c
    ../BSP/LED/: LED.C
    ../BSP/ws2812B/: ws2812B.c
    ../BSP/KEY/: key.c
    ../BSP/MOTOR/: motor.c
    ../BSP/MPU6050/: MPU6050.c
    ../BSP/IIC/: IOI2C.c
    ../BSP/ADC/: adc.c
    ../BSP/rtc/: rtc.c
    ../BSP/ENCODER/: encoder.c
    ../BSP/Esp8266_Wifi/: esp8266.c
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_i2c.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Documentation
    ./: readme.txt
    ../LstFlash/: STM32-FD-ucos.map
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 4.3.0
